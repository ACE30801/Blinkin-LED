# Keil uVision project LED_Control.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Control
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\01_WorkSpace\HAL\LED\inc;.\01_WorkSpace\MCAL\Gpio\Dio\inc;.\01_WorkSpace\MCAL\Gpio\Port\inc;.\01_WorkSpace\MCAL\Gpt\inc;.\01_WorkSpace\MCAL\IntCtrl\inc;.\01_WorkSpace\LIBS\Standard;.\01_WorkSpace\HAL\LED\inc;.\01_WorkSpace\MCAL\MCU\inc;..\..\..\Drivers\Common;..\..\..\Drivers\MCU\inc;.\01_WorkSpace\MCAL\CpuDriver\inc;.\01_WorkSpace\MCAL\Systick\inc;.\01_WorkSpace\Config\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group HAL
    ./01_WorkSpace/HAL/LED/src/: LED_Prog.c
  group MCAL
    ./01_WorkSpace/MCAL/Gpio/Dio/src/: Dio.c
    ./01_WorkSpace/MCAL/Gpio/Port/src/: Port.c
    ./01_WorkSpace/MCAL/IntCtrl/src/: IntCtrl.c
    ./01_WorkSpace/MCAL/CpuDriver/src/: Cpu_Driver.c
    ./01_WorkSpace/MCAL/Systick/src/: Systick.c
  group APP
    ./01_WorkSpace/APP/: main.c
  group Config
    ./01_WorkSpace/MCAL/Gpio/Port/src/: Port_Cfg.c
    ./01_WorkSpace/Config/src/: IntCtrl_Cfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
